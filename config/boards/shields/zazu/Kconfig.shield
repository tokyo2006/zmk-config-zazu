## config/boards/shields/zazu/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_ZAZU
    def_bool $(shields_list_contains,zazu)
```
